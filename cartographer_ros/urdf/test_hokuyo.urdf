Commit message: Update configuration files for hokuyo laser

File: cartographer_ros/urdf/test_hokuyo.urdf (robot description, URDF)
Before this commit: robot hokuyobot, 3 links, 2 joints
Joints:
- joint imu_link_joint: origin xyz=0 0 0 -> xyz=0 0 0 rpy=0 -3.142 -1.571
